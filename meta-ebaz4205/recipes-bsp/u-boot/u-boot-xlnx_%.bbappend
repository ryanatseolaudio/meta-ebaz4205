# Just force the compilation to use a safe built-in tree
EXTRA_OEMAKE:append = " DEVICE_TREE=zynq-zc702"
