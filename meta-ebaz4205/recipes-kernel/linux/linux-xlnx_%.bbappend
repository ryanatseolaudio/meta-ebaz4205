# Purely a placeholder now that DTS tasks have moved to the device-tree recipe
