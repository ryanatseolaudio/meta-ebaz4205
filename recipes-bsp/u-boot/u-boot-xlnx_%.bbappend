FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

# If you have specific defconfig adjustments for the EBAZ4205
SRC_URI += "file://0001-ebaz4205-board-config.patch"
