# Allow the FSBL to be built for our custom Zynq-7000 machine
COMPATIBLE_MACHINE:ebaz4205-zynq7 = "ebaz4205-zynq7"
